Commit message: added cartesian controller

File: snu_sdx_controller/dyros_robot_controller/fr3_controller/robot/fr3.urdf (robot description, URDF)
Before this commit: robot fr3, 10 links, 9 joints
Links:
- link fr3_link8: mass None -> 0.73
